// Moss Hollow: a little adventure in the four greens of the first handheld
// consoles, on the Guition ESP32-4848S040 (a 4-inch 480x480 touch screen).
//
// The look: a 160x144 screen in four shades of green, 16x16 tiles and
// sprites, an 8x8 font, a text box at the bottom, screens that slide into
// each other. Pixel size 2 makes the panel 240x240; the script draws the
// screen (320x288 on the panel) in a grey case, with a cross, A, B and
// START under it. The sketch reads the touch screen (up to three fingers)
// and sets a bit per button held in touchHeld; the whole left of the pad is
// the cross (the side of its middle the finger is on), A and B are whichever
// is nearer.
//
// The game: a wanderer looks for three crystal shards in nine screens of
// woods, ponds and rocks, and brings them to the shrine in the middle one.
// One shard is behind a locked door; the key is somewhere else. Slimes and
// bats; five hearts; falling sends the wanderer back to the shrine, with
// what was found kept.
//   the cross   walk
//   A           the sword
//   B           the map, while held
//   START       starts a game
// The art and the world are drawn as text in tools/data.py, which writes the
// arrays pasted below.
//
// Needs the modified LovyanGFX Bus_RGB driver (double frame buffer with
// show(), _frame_buffer, pixel_size, offset). Guition4848S040.h is the panel
// configuration.
//
// Board: ESP32S3 Dev Module, PSRAM "OPI PSRAM", Flash Size 16MB.
#include "Guition4848S040.h"
#include "script_executable.h"
#include "binding.h"

LGFX lcd;
uint16_t *frame_buffer;
static uint32_t _sizex = 480;
static uint32_t _sizey = 480;

// once a second: the frames shown, and the time the script takes for one
// (its steps and its drawing, between two show16()), so the frame rate it
// would reach without waiting for the panel
static uint32_t fpsFrames = 0;
static int64_t fpsStart = 0;
static int64_t scriptTime = 0;   // microseconds spent in the script this second
static int64_t leftShow = 0;     // when the last show16() returned

void show16() {
  int64_t in = esp_timer_get_time();
  if (leftShow != 0)
    scriptTime += in - leftShow;
  lcd._bus_instance.show();
  frame_buffer = (uint16_t *)lcd._bus_instance._frame_buffer;
  lcd._panel_instance.resetWriteBuffer();
  fpsFrames++;
  int64_t now = esp_timer_get_time();
  if (now - fpsStart >= 1000000) {
    float perFrame = (float)scriptTime / fpsFrames;
    printf("shown %.1f fps, script %.2f ms a frame (%.0f fps without waiting for the panel)\n",
           fpsFrames * 1000000.0f / (now - fpsStart), perFrame / 1000.0f, 1000000.0f / perFrame);
    fpsFrames = 0;
    scriptTime = 0;
    fpsStart = now;
  }
  leftShow = esp_timer_get_time();
}

void clearscreen() {
  memset(frame_buffer, 0, 480 * 480 * 2);
}

// pixel_size h: each cell is shown as h x h pixels, width x height cells
void setPixelsize(int h) {
  clearscreen();
  show16();
  clearscreen();
  lcd._bus_instance.offset = 0;
  lcd._bus_instance.pixel_size = h;
  _sizex = 480 / h;
  _sizey = 480 / h;
}

uint32_t scriptMillis() {
  return millis();
}

uint32_t scriptRand(uint32_t n) {
  return esp_random() % n;
}

// the backlight, 0 (off) to 255: a script can dim the screen
void scriptSetBrightness(int level) {
  lcd.setBrightness(level < 0 ? 0 : level > 255 ? 255 : level);
}

// --- the buttons, where the script draws them on the 240x240 case ---
// bits of touchHeld: 0 left, 1 right, 2 up, 3 down, 4 A, 5 B, 6 START
#define PAD_TOP 166
#define CROSS_X 56
#define CROSS_Y 204
#define A_X 200
#define A_Y 196
#define B_X 166
#define B_Y 212

static volatile uint32_t touchHeld = 0;

static uint32_t buttonAt(int x, int y) {
  if (y < PAD_TOP)
    return 0;
  // START, between the cross and B
  if (x >= 100 && x < 142 && y >= 214)
    return 1u << 6;
  // the cross: the side of its middle the finger is on
  if (x < 112) {
    int dx = x - CROSS_X, dy = y - CROSS_Y;
    if (abs(dx) < 6 && abs(dy) < 6)
      return 0;
    if (abs(dx) > abs(dy))
      return dx < 0 ? 1u << 0 : 1u << 1;
    return dy < 0 ? 1u << 2 : 1u << 3;
  }
  // A or B, the nearer
  if (x >= 142) {
    int da = (x - A_X) * (x - A_X) + (y - A_Y) * (y - A_Y);
    int db = (x - B_X) * (x - B_X) + (y - B_Y) * (y - B_Y);
    return da < db ? 1u << 4 : 1u << 5;
  }
  return 0;
}

static void touchTask(void *) {
  while (true) {
    lgfx::touch_point_t tp[3];
    int n = lcd.getTouchRaw(tp, 3);
    uint32_t held = 0;
    for (int k = 0; k < n; k++)
      held |= buttonAt(tp[k].x / 2, tp[k].y / 2);
    touchHeld = held;
    vTaskDelay(pdMS_TO_TICKS(16));
  }
}

char mossHollow[] = R"EOF(
// the frame buffer's width in pixels of the panel; at pixel size 2 the
// picture is 240x240 and its rows are STRIDE apart
#define STRIDE 480
// the screen: 160x144 in four shades, in a case; the top 16 rows of it are
// the hearts, the key and the shards, the 160x128 under them the world
#define LX 40
#define LY 12
#define LW 160
#define LH 144
#define TOP 16
// the game steps 30 times a second; positions in sixteenths of a pixel
#define STEP_MS 33
#define FP 16
#define SPEED 24
#define MAXHP 5
#define FOES 6
#define POOFS 6
#define SLIDE 16
// the buttons, a bit each in touchHeld
#define B_LEFT 0
#define B_RIGHT 1
#define B_UP 2
#define B_DOWN 3
#define B_A 4
#define B_B 5
#define B_START 6
// the tiles of the world (tools/data.py)
#define T_GRASS 0
#define T_FLOWERS 1
#define T_PATH 2
#define T_TREE 3
#define T_ROCK 4
#define T_WATER 5
#define T_WALL 6
#define T_LOCKED 7
#define T_SHRINE 8
#define T_KEY 9
#define T_SHARD 10
#define T_HEART 11
#define T_SLIME 12
#define T_BAT 13
#define T_START 14
#define T_OPEN 15

// art: 0 GRASS, 1 FLOWERS, 2 PATH, 3 TREE, 4 ROCK, 5 WATER0, 6 WATER1, 7 WALL, 8 DOOR, 9 DOOROPEN, 10 SHRINE, 11 HERO_D0, 12 HERO_D1, 13 HERO_U0, 14 HERO_U1, 15 HERO_S0, 16 HERO_S1, 17 SWORD_D, 18 SWORD_U, 19 SWORD_S, 20 SLIME0, 21 SLIME1, 22 BAT0, 23 BAT1, 24 KEY, 25 SHARD, 26 HEART, 27 POOF
#define A_GRASS 0
#define A_FLOWERS 1
#define A_PATH 2
#define A_TREE 3
#define A_ROCK 4
#define A_WATER0 5
#define A_WATER1 6
#define A_WALL 7
#define A_DOOR 8
#define A_DOOROPEN 9
#define A_SHRINE 10
#define A_HERO_D0 11
#define A_HERO_D1 12
#define A_HERO_U0 13
#define A_HERO_U1 14
#define A_HERO_S0 15
#define A_HERO_S1 16
#define A_SWORD_D 17
#define A_SWORD_U 18
#define A_SWORD_S 19
#define A_SLIME0 20
#define A_SLIME1 21
#define A_BAT0 22
#define A_BAT1 23
#define A_KEY 24
#define A_SHARD 25
#define A_HEART 26
#define A_POOF 27
#define I_HUD_HEART 0
#define I_HUD_EMPTY 1
#define I_HUD_KEY 2
#define I_HUD_SHARD 3
uint8_t art[7168] = {0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 3, 2, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 2, 3, 2, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 3, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 2, 3, 2, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 2, 3, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 2, 2, 2, 2, 2, 2, 0, 0, 0, 0, 0, 0, 0, 0, 2, 2, 1, 1, 1, 1, 1, 1, 2, 2, 0, 0, 0, 0, 0, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 2, 0, 0, 0, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 2, 0, 0, 2, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 2, 0, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 1, 2, 0, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 0, 0, 2, 2, 2, 2, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 0, 0, 0, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 0, 0, 0, 0, 0, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 2, 2, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 1, 1, 1, 1, 1, 1, 3, 3, 0, 0, 0, 0, 0, 3, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 3, 0, 0, 0, 3, 1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 3, 0, 0, 3, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 3, 0, 3, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 3, 3, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 3, 3, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 3, 3, 2, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 3, 3, 3, 2, 2, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 0, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 0, 0, 0, 3, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 3, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 2, 2, 2, 3, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 3, 2, 1, 1, 1, 1, 1, 1, 1, 3, 2, 1, 1, 2, 2, 2, 3, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 0, 0, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 0, 0, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 0, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 0, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 3, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 3, 3, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 3, 3, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 3, 3, 1, 2, 1, 1, 3, 2, 2, 2, 2, 3, 1, 1, 2, 1, 3, 3, 1, 2, 1, 3, 2, 2, 2, 2, 2, 2, 3, 1, 2, 1, 3, 3, 1, 2, 1, 3, 2, 1, 1, 1, 1, 2, 3, 1, 2, 1, 3, 3, 1, 2, 1, 3, 2, 1, 0, 0, 1, 2, 3, 1, 2, 1, 3, 3, 1, 2, 1, 3, 2, 1, 0, 0, 1, 2, 3, 1, 2, 1, 3, 3, 1, 2, 1, 3, 2, 1, 1, 1, 1, 2, 3, 1, 2, 1, 3, 3, 1, 2, 1, 3, 2, 2, 2, 2, 2, 2, 3, 1, 2, 1, 3, 3, 1, 2, 1, 1, 3, 2, 2, 2, 2, 3, 1, 1, 2, 1, 3, 3, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 3, 3, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 3, 3, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 3, 3, 3, 3, 3, 3, 2, 2, 3, 4, 4, 4, 4, 3, 2, 3, 0, 0, 0, 0, 0, 0, 3, 2, 3, 4, 4, 4, 4, 3, 3, 0, 3, 0, 0, 0, 0, 3, 0, 3, 3, 4, 4, 4, 4, 4, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 4, 4, 4, 4, 4, 4, 3, 3, 0, 0, 0, 0, 0, 0, 3, 3, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 4, 4, 4, 4, 3, 1, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 1, 4, 4, 4, 3, 1, 1, 3, 2, 2, 2, 2, 2, 2, 3, 1, 1, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 3, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 3, 3, 3, 3, 3, 3, 2, 2, 3, 4, 4, 4, 4, 3, 2, 3, 0, 0, 0, 0, 0, 0, 3, 2, 3, 4, 4, 4, 4, 3, 3, 0, 3, 0, 0, 0, 0, 3, 0, 3, 3, 4, 4, 4, 4, 4, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 4, 4, 4, 4, 4, 4, 3, 3, 0, 0, 0, 0, 0, 0, 3, 3, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 4, 4, 4, 4, 3, 1, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 1, 4, 4, 4, 3, 1, 1, 3, 2, 2, 2, 2, 2, 2, 3, 1, 1, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 4, 3, 3, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 4, 4, 4, 4, 3, 1, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 1, 4, 4, 4, 3, 1, 1, 3, 2, 2, 2, 2, 2, 2, 3, 1, 1, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 3, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 4, 4, 4, 4, 3, 1, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 1, 4, 4, 4, 3, 1, 1, 3, 2, 2, 2, 2, 2, 2, 3, 1, 1, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 4, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 3, 3, 3, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 3, 0, 0, 0, 4, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 3, 0, 0, 3, 0, 3, 0, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 0, 0, 0, 0, 4, 3, 4, 4, 4, 4, 4, 3, 3, 2, 2, 3, 0, 0, 0, 3, 3, 4, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 1, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 1, 1, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 3, 3, 3, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 3, 0, 0, 0, 4, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 3, 0, 0, 3, 0, 3, 0, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 0, 0, 0, 0, 4, 3, 4, 4, 4, 4, 4, 3, 3, 2, 2, 3, 0, 0, 0, 3, 3, 4, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 1, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 1, 1, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 2, 2, 3, 4, 4, 3, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 1, 1, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 3, 2, 2, 0, 3, 2, 2, 2, 2, 0, 3, 2, 2, 3, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 3, 2, 2, 2, 2, 3, 3, 3, 3, 2, 2, 2, 2, 3, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 1, 1, 2, 2, 3, 3, 4, 4, 4, 4, 4, 3, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 3, 2, 2, 0, 3, 2, 2, 2, 2, 0, 3, 2, 2, 3, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 3, 2, 2, 2, 2, 2, 3, 3, 3, 3, 2, 2, 2, 2, 2, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 2, 3, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 3, 2, 3, 3, 2, 2, 3, 4, 3, 2, 2, 2, 2, 3, 4, 3, 2, 2, 3, 3, 2, 2, 2, 3, 2, 0, 0, 0, 0, 2, 4, 3, 2, 2, 3, 4, 3, 2, 2, 2, 3, 0, 0, 0, 0, 3, 4, 2, 2, 2, 3, 4, 4, 3, 2, 2, 2, 2, 3, 3, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 3, 3, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 2, 0, 0, 0, 0, 2, 3, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 3, 0, 0, 3, 2, 2, 3, 4, 4, 4, 4, 4, 3, 2, 2, 2, 2, 3, 3, 2, 2, 2, 2, 3, 4, 4, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 3, 2, 2, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 2, 2, 3, 3, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 2, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 3, 3, 3, 3, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 3, 0, 0, 3, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 3, 3, 3, 3, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 0, 0, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 0, 0, 0, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 3, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 0, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 1, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 0, 1, 1, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 1, 1, 1, 1, 3, 4, 4, 4, 4, 4, 4, 4, 3, 0, 0, 0, 1, 1, 1, 1, 2, 3, 4, 4, 4, 4, 4, 4, 3, 0, 0, 1, 1, 1, 1, 1, 2, 3, 4, 4, 4, 4, 4, 4, 3, 0, 1, 1, 1, 1, 1, 2, 2, 3, 4, 4, 4, 4, 4, 4, 3, 0, 1, 1, 1, 1, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 3, 0, 1, 1, 1, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 1, 1, 2, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 1, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 1, 2, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 1, 2, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 3, 0, 0, 0, 3, 4, 3, 1, 1, 1, 3, 4, 4, 4, 4, 3, 0, 0, 0, 0, 0, 3, 1, 1, 1, 1, 1, 3, 4, 4, 4, 3, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 3, 4, 4, 4, 3, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 3, 4, 4, 4, 4, 3, 0, 0, 0, 1, 1, 1, 1, 1, 1, 3, 4, 4, 4, 4, 4, 4, 3, 0, 0, 1, 1, 1, 1, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 0, 1, 1, 1, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 1, 1, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 1, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 0, 0, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 0, 0, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 0, 0, 4, 0, 4, 4, 0, 0, 4, 4, 0, 4, 0, 0, 4, 4, 0, 0, 4, 0, 4, 4, 0, 0, 4, 4, 0, 4, 0, 0, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 0, 0, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 4, 0, 4, 4, 4, 0, 0, 4, 4, 4, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 0, 0, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4};
uint8_t icons[256] = {4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 3, 3, 4, 4, 3, 0, 0, 3, 1, 1, 3, 4, 3, 0, 0, 0, 1, 1, 3, 4, 4, 3, 0, 0, 1, 3, 4, 4, 4, 4, 3, 0, 3, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 3, 3, 4, 4, 3, 4, 4, 3, 4, 4, 3, 4, 3, 4, 4, 4, 4, 4, 3, 4, 4, 3, 4, 4, 4, 3, 4, 4, 4, 4, 3, 4, 3, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 3, 4, 4, 3, 4, 4, 4, 4, 3, 4, 4, 3, 3, 3, 3, 3, 4, 3, 3, 3, 4, 3, 4, 3, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 3, 0, 3, 4, 4, 4, 4, 4, 3, 0, 1, 3, 4, 4, 4, 3, 0, 0, 1, 1, 3, 4, 4, 3, 0, 1, 1, 1, 3, 4, 4, 4, 3, 1, 1, 3, 4, 4, 4, 4, 3, 1, 3, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4};
uint8_t world[720] = {3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 0, 6, 6, 6, 6, 6, 6, 0, 3, 3, 0, 6, 0, 10, 0, 0, 6, 0, 3, 3, 0, 6, 0, 0, 0, 0, 6, 0, 0, 3, 0, 6, 6, 6, 7, 6, 6, 0, 0, 3, 0, 1, 0, 0, 0, 0, 0, 0, 3, 3, 0, 0, 0, 0, 12, 0, 0, 0, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 5, 5, 5, 5, 0, 0, 3, 3, 0, 5, 5, 5, 5, 5, 5, 0, 3, 0, 0, 5, 5, 4, 4, 5, 5, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 3, 0, 12, 0, 0, 0, 0, 12, 0, 3, 3, 0, 0, 11, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 5, 0, 0, 0, 5, 10, 3, 3, 0, 0, 5, 0, 5, 0, 5, 0, 3, 0, 0, 0, 5, 0, 5, 0, 5, 0, 3, 0, 0, 0, 0, 0, 5, 0, 0, 0, 3, 3, 0, 13, 0, 0, 5, 5, 5, 0, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 0, 4, 0, 0, 0, 0, 4, 0, 3, 3, 0, 0, 0, 4, 4, 0, 0, 0, 3, 3, 0, 12, 0, 0, 0, 0, 0, 0, 0, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 0, 4, 0, 0, 12, 0, 4, 0, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 1, 0, 0, 2, 2, 0, 0, 1, 3, 3, 0, 0, 0, 2, 2, 0, 0, 0, 3, 2, 2, 2, 2, 8, 8, 2, 2, 2, 2, 2, 2, 2, 2, 8, 8, 2, 2, 2, 2, 3, 0, 0, 0, 2, 2, 0, 0, 0, 3, 3, 1, 0, 0, 14, 2, 0, 0, 1, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 0, 0, 3, 0, 0, 3, 0, 0, 3, 3, 0, 13, 0, 0, 0, 0, 0, 0, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 0, 0, 0, 0, 0, 0, 3, 0, 0, 3, 3, 0, 0, 3, 0, 0, 0, 0, 0, 3, 3, 0, 0, 0, 0, 0, 13, 0, 0, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 0, 4, 4, 4, 4, 4, 0, 0, 3, 3, 0, 4, 0, 10, 0, 4, 0, 0, 0, 3, 0, 4, 0, 0, 0, 4, 0, 0, 0, 3, 0, 4, 4, 0, 4, 4, 0, 0, 3, 3, 0, 0, 13, 0, 0, 13, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 0, 1, 0, 0, 0, 0, 1, 0, 3, 3, 0, 0, 12, 0, 0, 12, 0, 0, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 4, 4, 0, 0, 0, 0, 3, 0, 1, 0, 0, 0, 0, 1, 0, 3, 3, 0, 0, 0, 11, 0, 0, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 3, 3, 3, 0, 5, 5, 5, 5, 5, 0, 0, 3, 3, 0, 5, 9, 0, 0, 0, 5, 0, 3, 0, 0, 5, 0, 0, 0, 0, 5, 0, 3, 0, 0, 0, 5, 5, 0, 5, 5, 0, 3, 3, 0, 0, 0, 0, 0, 0, 0, 0, 3, 3, 0, 0, 12, 0, 0, 12, 0, 0, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3};

// the games' 8x8 font, 0-9 then A-Z (ChromaQuest/tools/font8.py)
uint8_t font8[288] = {126, 199, 207, 219, 243, 227, 126, 0, 24, 56, 120, 24, 24, 24, 126, 0, 126, 195, 6, 28, 112, 192, 255, 0, 126, 195, 3, 62, 3, 195, 126, 0, 14, 30, 54, 102, 255, 6, 6, 0, 255, 192, 254, 3, 3, 195, 126, 0, 62, 96, 192, 254, 195, 195, 126, 0, 255, 195, 6, 12, 24, 24, 24, 0, 126, 195, 195, 126, 195, 195, 126, 0, 126, 195, 195, 127, 3, 6, 124, 0, 60, 102, 195, 195, 255, 195, 195, 0, 254, 195, 195, 254, 195, 195, 254, 0, 126, 195, 192, 192, 192, 195, 126, 0, 252, 198, 195, 195, 195, 198, 252, 0, 255, 192, 192, 252, 192, 192, 255, 0, 255, 192, 192, 252, 192, 192, 192, 0, 126, 195, 192, 207, 195, 195, 126, 0, 195, 195, 195, 255, 195, 195, 195, 0, 126, 24, 24, 24, 24, 24, 126, 0, 63, 6, 6, 6, 198, 198, 124, 0, 198, 204, 216, 240, 216, 204, 198, 0, 192, 192, 192, 192, 192, 192, 255, 0, 195, 231, 255, 219, 195, 195, 195, 0, 195, 227, 243, 219, 207, 199, 195, 0, 126, 195, 195, 195, 195, 195, 126, 0, 254, 195, 195, 254, 192, 192, 192, 0, 126, 195, 195, 195, 203, 198, 123, 0, 254, 195, 195, 254, 204, 198, 195, 0, 126, 195, 192, 126, 3, 195, 126, 0, 255, 24, 24, 24, 24, 24, 24, 0, 195, 195, 195, 195, 195, 195, 126, 0, 195, 195, 195, 195, 102, 60, 24, 0, 195, 195, 195, 219, 255, 231, 195, 0, 195, 102, 60, 24, 60, 102, 195, 0, 195, 195, 102, 60, 24, 24, 24, 0, 255, 6, 12, 24, 48, 96, 255, 0};

// a 3x5 font for the words on the case: 0-9, A-Z
int font3[36] = {31599, 11415, 29671, 29647, 23497, 31183, 31215, 29330, 31727, 31695,
                 11245, 27566, 14627, 27502, 31143, 31140, 14699, 23533, 29847, 4714,
                 23861, 18727, 24557, 27501, 11114, 27556, 11123, 27565, 14478, 29842,
                 23407, 23402, 23549, 23213, 23186, 29351};

// the four shades of the screen, lightest first, and the case's colours
uint16_t shade[4];
uint16_t caseLight;
uint16_t caseShade;
uint16_t bezel;
uint16_t padDark;
uint16_t padLit;
uint16_t buttonRed;
uint16_t buttonLit;
uint16_t ledRed;
// a circle's half widths, row by row (radius 14)
int span[15];

// the world as it is now: what was taken stays taken
uint8_t tiles[720];
int visited[9];
int room;

// the wanderer
int hx;
int hy;
int facing;          // 0 down, 1 up, 2 left, 3 right
int walking;
int hp;
int hurt;            // steps left of not being hurt again
int swordTime;
int hasKey;
int shards;
int placed;

// the slimes and the bats of this screen
int ex[6];
int ey[6];
int etype[6];        // 1 slime, 2 bat, 0 none
int ehp[6];
int edir[6];
int etime[6];
int eflash[6];

int px[6];
int py[6];
int ptime[6];

int state;           // 0 title, 1 playing, 2 sliding to the next screen, 3 the end
int stateTime;
int slideDir;        // 0 down, 1 up, 2 left, 3 right
int oldRoom;
int message;
int messageTime;
int lockedTime;
int frame;
int playSteps;
int falls;
uint32_t held;
uint32_t before;

// r, g, b (0-255) as the frame buffer wants them: RGB565, byte swapped
uint16_t pack(int r, int g, int b)
{
   int v = ((r & 248) << 8) | ((g & 252) << 3) | (b >> 3);
   return ((v & 255) << 8) | (v >> 8);
}

void makeColours()
{
   shade[0] = pack(155, 188, 15);
   shade[1] = pack(139, 172, 15);
   shade[2] = pack(48, 98, 48);
   shade[3] = pack(15, 56, 15);
   caseLight = pack(200, 198, 192);
   caseShade = pack(160, 158, 156);
   bezel = pack(86, 84, 104);
   padDark = pack(40, 40, 44);
   padLit = pack(110, 110, 120);
   buttonRed = pack(140, 24, 72);
   buttonLit = pack(220, 80, 140);
   ledRed = pack(230, 30, 40);
   for (int dy = 0; dy < 15; dy++)
   {
      int w = 0;
      while ((w + 1) * (w + 1) + dy * dy <= 196)
         w++;
      span[dy] = w;
   }
}

// --- the case: plain fills over the whole 240x240 ---

void fill(int x, int y, int w, int h, uint16_t c)
{
   for (int j = 0; j < h; j++)
   {
      int row = (y + j) * STRIDE + x;
      for (int i = 0; i < w; i++)
         led16[row + i] = c;
   }
}

void disc(int cx, int cy, uint16_t c)
{
   for (int dy = -14; dy <= 14; dy++)
   {
      int w = span[dy];
      if (dy < 0)
         w = span[0 - dy];
      fill(cx - w, cy + dy, 2 * w + 1, 1, c);
   }
}

void word3(char *s, int x, int y, uint16_t c)
{
   int i = 0;
   while (s[i] != 0)
   {
      int ch = s[i];
      int g = -1;
      if (ch >= 48 && ch <= 57)
         g = ch - 48;
      if (ch >= 65 && ch <= 90)
         g = ch - 55;
      if (g >= 0)
      {
         int bits = font3[g];
         for (int r = 0; r < 5; r++)
            for (int b = 0; b < 3; b++)
               if ((bits >> ((4 - r) * 3 + 2 - b)) & 1)
                  led16[(y + r) * STRIDE + x + b] = c;
      }
      x = x + 4;
      i++;
   }
}

int btn(int b)
{
   return (held >> b) & 1;
}

int btnp(int b)
{
   if (((held >> b) & 1) == 1 && ((before >> b) & 1) == 0)
      return 1;
   return 0;
}

void drawCase()
{
   // around the screen: the case, the bezel, the power light
   fill(0, 0, 240, LY - 8, caseLight);
   fill(0, LY - 8, LX - 12, LH + 16, caseLight);
   fill(LX + LW + 12, LY - 8, 240 - LX - LW - 12, LH + 16, caseLight);
   fill(0, LY + LH + 8, 240, 240 - LY - LH - 8, caseLight);
   fill(LX - 12, LY - 8, LW + 24, 8, bezel);
   fill(LX - 12, LY + LH, LW + 24, 8, bezel);
   fill(LX - 12, LY, 12, LH, bezel);
   fill(LX + LW, LY, 12, LH, bezel);
   fill(LX - 8, LY + 40, 4, 4, ledRed);
   fill(0, 238, 240, 2, caseShade);
   // the cross
   uint16_t c = padDark;
   fill(44, 180, 24, 48, padDark);
   fill(32, 192, 48, 24, padDark);
   if (btn(B_UP) == 1)
      fill(47, 181, 18, 16, padLit);
   if (btn(B_DOWN) == 1)
      fill(47, 211, 18, 16, padLit);
   if (btn(B_LEFT) == 1)
      fill(33, 195, 16, 18, padLit);
   if (btn(B_RIGHT) == 1)
      fill(63, 195, 16, 18, padLit);
   fill(53, 201, 6, 6, caseShade);
   // B and A
   c = buttonRed;
   if (btn(B_B) == 1)
      c = buttonLit;
   disc(166, 212, c);
   c = buttonRed;
   if (btn(B_A) == 1)
      c = buttonLit;
   disc(200, 196, c);
   word3("B", 165, 229, bezel);
   word3("A", 199, 213, bezel);
   // start
   c = caseShade;
   if (btn(B_START) == 1)
      c = padLit;
   fill(108, 222, 24, 6, c);
   word3("START", 110, 230, bezel);
   word3("MAP B", 153, 172, caseShade);
}

// --- the screen: four shades, clipped to its rows clipTop..clipBottom ---

int clipTop;
int clipBottom;

void lfill(int x, int y, int w, int h, int s)
{
   if (x < 0)
   {
      w = w + x;
      x = 0;
   }
   if (y < clipTop)
   {
      h = h - (clipTop - y);
      y = clipTop;
   }
   if (x + w > LW)
      w = LW - x;
   if (y + h > clipBottom)
      h = clipBottom - y;
   if (w <= 0 || h <= 0)
      return;
   fill(LX + x, LY + y, w, h, shade[s]);
}

// a 16x16 picture of art[], flipped left to right when flip is 1
void blit(int n, int x, int y, int flip)
{
   int base = n * 256;
   for (int j = 0; j < 16; j++)
   {
      int yy = y + j;
      if (yy >= clipTop && yy < clipBottom)
      {
         int row = (LY + yy) * STRIDE + LX;
         for (int i = 0; i < 16; i++)
         {
            int xx = x + i;
            if (xx >= 0 && xx < LW)
            {
               int c = art[base + j * 16 + i];
               if (flip == 1)
                  c = art[base + j * 16 + 15 - i];
               if (c < 4)
                  led16[row + xx] = shade[c];
            }
         }
      }
   }
}

// a whole tile, inside the screen: no clipping, no clear pixels
void tile(int n, int x, int y)
{
   int base = n * 256;
   for (int j = 0; j < 16; j++)
   {
      int row = (LY + y + j) * STRIDE + LX + x;
      int a = base + j * 16;
      for (int i = 0; i < 16; i++)
         led16[row + i] = shade[art[a + i]];
   }
}

void icon(int n, int x, int y)
{
   int base = n * 64;
   for (int j = 0; j < 8; j++)
      for (int i = 0; i < 8; i++)
      {
         int c = icons[base + j * 8 + i];
         if (c < 4)
            led16[(LY + y + j) * STRIDE + LX + x + i] = shade[c];
      }
}

// capitals, digits and spaces in the 8x8 font, 9 dots apart, one shade
void text(char *s, int x, int y, int sc, int c)
{
   int i = 0;
   while (s[i] != 0)
   {
      int ch = s[i];
      int g = -1;
      if (ch >= 48 && ch <= 57)
         g = ch - 48;
      if (ch >= 65 && ch <= 90)
         g = ch - 55;
      if (g >= 0)
         for (int r = 0; r < 8; r++)
         {
            int bits = font8[g * 8 + r];
            for (int b = 0; b < 8; b++)
               if (((bits >> (7 - b)) & 1) == 1)
                  lfill(x + b * sc, y + r * sc, sc, sc, c);
         }
      x = x + 9 * sc;
      i++;
   }
}

int d[6];
// a number in the 8x8 font; returns where it ends
int number(int v, int x, int y, int c)
{
   int n = 0;
   while (v > 0 || n == 0)
   {
      d[n] = v % 10;
      v = v / 10;
      n++;
   }
   for (int k = n - 1; k >= 0; k--)
   {
      int g = d[k];
      for (int r = 0; r < 8; r++)
      {
         int bits = font8[g * 8 + r];
         for (int b = 0; b < 8; b++)
            if (((bits >> (7 - b)) & 1) == 1)
               lfill(x + b, y + r, 1, 1, c);
      }
      x = x + 9;
   }
   return x;
}

// --- the world ---

int tileAt(int r, int tx, int ty)
{
   return tiles[r * 80 + ty * 10 + tx];
}

int blocks(int t)
{
   if (t == T_TREE || t == T_ROCK || t == T_WATER || t == T_WALL || t == T_LOCKED || t == T_SHRINE)
      return 1;
   return 0;
}

// does a box (in pixels of this screen) touch something solid? off the
// screen is open: that is the way to the next one
int solid(int x, int y, int w, int h)
{
   for (int ty = y >> 4; ty <= (y + h - 1) >> 4; ty++)
      for (int tx = x >> 4; tx <= (x + w - 1) >> 4; tx++)
         if (tx >= 0 && tx < 10 && ty >= 0 && ty < 8)
            if (blocks(tileAt(room, tx, ty)) == 1)
               return 1;
   return 0;
}

void poof(int x, int y)
{
   for (int k = 0; k < POOFS; k++)
      if (ptime[k] == 0)
      {
         px[k] = x;
         py[k] = y;
         ptime[k] = 12;
         return;
      }
}

void say(int m)
{
   message = m;
   messageTime = 75;
}

// a screen's slimes and bats come back each time it is entered
void enterRoom(int r)
{
   room = r;
   visited[r] = 1;
   for (int k = 0; k < FOES; k++)
      etype[k] = 0;
   for (int k = 0; k < POOFS; k++)
      ptime[k] = 0;
   int n = 0;
   for (int i = 0; i < 80; i++)
   {
      int t = tiles[r * 80 + i];
      if ((t == T_SLIME || t == T_BAT) && n < FOES)
      {
         ex[n] = (i % 10) * 16 * FP;
         ey[n] = (i / 10) * 16 * FP;
         etype[n] = 1;
         ehp[n] = 2;
         if (t == T_BAT)
         {
            etype[n] = 2;
            ehp[n] = 1;
         }
         edir[n] = rand(4);
         etime[n] = 20 + rand(40);
         eflash[n] = 0;
         n++;
      }
   }
}

void wakeAtShrine()
{
   hx = 64 * FP;
   hy = 96 * FP;
   facing = 1;
   hp = MAXHP;
   enterRoom(4);
}

void newGame()
{
   for (int i = 0; i < 720; i++)
      tiles[i] = world[i];
   for (int i = 0; i < 9; i++)
      visited[i] = 0;
   hp = MAXHP;
   hurt = 0;
   hasKey = 0;
   shards = 0;
   placed = 0;
   falls = 0;
   playSteps = 0;
   swordTime = 0;
   message = 0;
   messageTime = 0;
   wakeAtShrine();
   state = 1;
}


// --- one step ---

void hurtHero(int fromX, int fromY)
{
   if (hurt > 0)
      return;
   hp--;
   hurt = 45;
   // pushed away from what hit
   int dx = 0;
   int dy = 0;
   if (hx / FP < fromX)
      dx = -6;
   else
      dx = 6;
   if (hy / FP < fromY)
      dy = -6;
   else
      dy = 6;
   if (solid(hx / FP + dx + 3, hy / FP + 8, 10, 7) == 0)
      hx = hx + dx * FP;
   if (solid(hx / FP + 3, hy / FP + dy + 8, 10, 7) == 0)
      hy = hy + dy * FP;
   if (hp <= 0)
   {
      falls++;
      poof(hx / FP, hy / FP);
      wakeAtShrine();
      say(6);
   }
}

void knock(int tx, int ty)
{
   if (hasKey == 1)
   {
      tiles[room * 80 + ty * 10 + tx] = T_OPEN;
      say(4);
   }
   else if (lockedTime == 0)
   {
      say(3);
      lockedTime = 90;
   }
}

void moveHero()
{
   int dx = 0;
   int dy = 0;
   if (swordTime == 0)
   {
      if (btn(B_LEFT) == 1)
      {
         dx = -1;
         facing = 2;
      }
      if (btn(B_RIGHT) == 1)
      {
         dx = 1;
         facing = 3;
      }
      if (btn(B_UP) == 1)
      {
         dy = -1;
         facing = 1;
      }
      if (btn(B_DOWN) == 1)
      {
         dy = 1;
         facing = 0;
      }
   }
   walking = 0;
   if (dx != 0)
   {
      int nx = hx + dx * SPEED;
      if (solid(nx / FP + 3, hy / FP + 8, 10, 7) == 0)
      {
         hx = nx;
         walking = 1;
      }
      else
      {
         // slide round a corner: a step aside when only a corner blocks
         if (solid(nx / FP + 3, hy / FP + 4, 10, 7) == 0)
            hy = hy - 8;
         else if (solid(nx / FP + 3, hy / FP + 12, 10, 7) == 0)
            hy = hy + 8;
         // a locked door, pushed
         int tx = (nx / FP + 8 + dx * 6) >> 4;
         int ty = (hy / FP + 11) >> 4;
         if (tx >= 0 && tx < 10 && ty >= 0 && ty < 8)
            if (tileAt(room, tx, ty) == T_LOCKED)
               knock(tx, ty);
      }
   }
   if (dy != 0)
   {
      int ny = hy + dy * SPEED;
      if (solid(hx / FP + 3, ny / FP + 8, 10, 7) == 0)
      {
         hy = ny;
         walking = 1;
      }
      else
      {
         if (solid(hx / FP - 1, ny / FP + 8, 10, 7) == 0)
            hx = hx - 8;
         else if (solid(hx / FP + 7, ny / FP + 8, 10, 7) == 0)
            hx = hx + 8;
         int tx = (hx / FP + 8) >> 4;
         int ty = (ny / FP + 11 + dy * 5) >> 4;
         if (tx >= 0 && tx < 10 && ty >= 0 && ty < 8)
            if (tileAt(room, tx, ty) == T_LOCKED)
               knock(tx, ty);
      }
   }

   // A: the sword
   if (swordTime > 0)
      swordTime--;
   if (btnp(B_A) == 1 && swordTime == 0)
      swordTime = 10;

   // what is underfoot
   int cx = (hx / FP + 8) >> 4;
   int cy = (hy / FP + 11) >> 4;
   if (cx >= 0 && cx < 10 && cy >= 0 && cy < 8)
   {
      int t = tileAt(room, cx, cy);
      if (t == T_KEY)
      {
         hasKey = 1;
         tiles[room * 80 + cy * 10 + cx] = T_GRASS;
         say(1);
      }
      if (t == T_SHARD)
      {
         shards++;
         tiles[room * 80 + cy * 10 + cx] = T_GRASS;
         say(2);
      }
      if (t == T_HEART)
      {
         if (hp < MAXHP)
            hp++;
         tiles[room * 80 + cy * 10 + cx] = T_GRASS;
      }
   }
   // next to the shrine with shards not yet given
   if (room == 4 && shards > placed)
   {
      int sx = hx / FP + 8 - 80;
      int sy = hy / FP + 8 - 64;
      if (sx > -32 && sx < 32 && sy > -32 && sy < 32)
      {
         placed = shards;
         say(5);
         if (placed == 3)
         {
            state = 3;
            stateTime = 0;
         }
      }
   }
   if (hurt > 0)
      hurt--;
   if (lockedTime > 0)
      lockedTime--;

   // off an edge: the next screen slides in
   int x = hx / FP;
   int y = hy / FP;
   int to = -1;
   if (x + 3 < 0 && room % 3 > 0)
   {
      to = room - 1;
      slideDir = 2;
   }
   if (x + 13 > LW && room % 3 < 2)
   {
      to = room + 1;
      slideDir = 3;
   }
   if (y + 8 < 0 && room >= 3)
   {
      to = room - 3;
      slideDir = 1;
   }
   if (y + 15 > LH - TOP && room < 6)
   {
      to = room + 3;
      slideDir = 0;
   }
   if (to >= 0)
   {
      oldRoom = room;
      enterRoom(to);
      // in at the opposite edge, just inside it
      if (slideDir == 2)
         hx = (LW - 13) * FP;
      if (slideDir == 3)
         hx = -3 * FP;
      if (slideDir == 1)
         hy = (LH - TOP - 15) * FP;
      if (slideDir == 0)
         hy = -8 * FP;
      state = 2;
      stateTime = 0;
   }
}


// the sword's reach this step, or w = 0
int sx0;
int sy0;
int sw;

void swordBox()
{
   sw = 0;
   if (swordTime < 2 || swordTime > 8)
      return;
   int x = hx / FP;
   int y = hy / FP;
   sw = 16;
   sx0 = x;
   sy0 = y + 12;
   if (facing == 1)
      sy0 = y - 12;
   if (facing == 2)
   {
      sx0 = x - 12;
      sy0 = y + 2;
   }
   if (facing == 3)
   {
      sx0 = x + 12;
      sy0 = y + 2;
   }
}

void moveFoes()
{
   swordBox();
   int hxp = hx / FP;
   int hyp = hy / FP;
   for (int k = 0; k < FOES; k++)
   {
      if (etype[k] == 0)
         continue;
      int x = ex[k] / FP;
      int y = ey[k] / FP;
      if (eflash[k] > 0)
         eflash[k] = eflash[k] - 1;
      if (etype[k] == 1)
      {
         // a slime: a while one way, then another
         etime[k] = etime[k] - 1;
         if (etime[k] <= 0)
         {
            edir[k] = rand(5);
            etime[k] = 20 + rand(40);
         }
         int dx = 0;
         int dy = 0;
         if (edir[k] == 0)
            dy = 8;
         if (edir[k] == 1)
            dy = -8;
         if (edir[k] == 2)
            dx = -8;
         if (edir[k] == 3)
            dx = 8;
         int nx = ex[k] + dx;
         int ny = ey[k] + dy;
         if (nx < 0 || ny < 0 || nx > (LW - 16) * FP || ny > (LH - TOP - 16) * FP || solid(nx / FP + 2, ny / FP + 6, 12, 9) == 1)
            etime[k] = 0;
         else
         {
            ex[k] = nx;
            ey[k] = ny;
         }
      }
      else
      {
         // a bat: flutters, and comes for the wanderer when near
         int ddx = hxp - x;
         int ddy = hyp - y;
         int near = 0;
         if (ddx > -64 && ddx < 64 && ddy > -64 && ddy < 64)
            near = 1;
         int vx = 0;
         int vy = 0;
         if (near == 1 && hurt == 0)
         {
            if (ddx > 2)
               vx = 11;
            if (ddx < -2)
               vx = -11;
            if (ddy > 2)
               vy = 11;
            if (ddy < -2)
               vy = -11;
         }
         else
         {
            vx = (rand(3) - 1) * 10;
            vy = (rand(3) - 1) * 10;
         }
         ex[k] = ex[k] + vx;
         ey[k] = ey[k] + vy;
         if (ex[k] < 0)
            ex[k] = 0;
         if (ey[k] < 0)
            ey[k] = 0;
         if (ex[k] > (LW - 16) * FP)
            ex[k] = (LW - 16) * FP;
         if (ey[k] > (LH - TOP - 16) * FP)
            ey[k] = (LH - TOP - 16) * FP;
      }
      x = ex[k] / FP;
      y = ey[k] / FP;
      // the sword
      if (sw > 0 && eflash[k] == 0 && x + 14 > sx0 && x + 2 < sx0 + sw && y + 14 > sy0 && y + 4 < sy0 + sw)
      {
         ehp[k] = ehp[k] - 1;
         eflash[k] = 12;
         // knocked back, away from the wanderer
         int kx = 0;
         int ky = 0;
         if (facing == 0)
            ky = 10;
         if (facing == 1)
            ky = -10;
         if (facing == 2)
            kx = -10;
         if (facing == 3)
            kx = 10;
         if (solid(x + kx + 2, y + ky + 6, 12, 9) == 0 && x + kx >= 0 && y + ky >= 0 && x + kx <= LW - 16 && y + ky <= LH - TOP - 16)
         {
            ex[k] = ex[k] + kx * FP;
            ey[k] = ey[k] + ky * FP;
         }
         if (ehp[k] <= 0)
         {
            etype[k] = 0;
            poof(x, y);
            // now and then a heart, where the grass is free
            int tx = (x + 8) >> 4;
            int ty = (y + 8) >> 4;
            if (rand(3) == 0 && tileAt(room, tx, ty) == T_GRASS)
               tiles[room * 80 + ty * 10 + tx] = T_HEART;
            continue;
         }
      }
      // touching the wanderer
      if (x + 13 > hxp + 3 && x + 3 < hxp + 13 && y + 14 > hyp + 4 && y + 5 < hyp + 15)
         hurtHero(x + 8, y + 8);
   }
   for (int k = 0; k < POOFS; k++)
      if (ptime[k] > 0)
         ptime[k] = ptime[k] - 1;
}

void update()
{
   frame++;
   if (messageTime > 0)
      messageTime--;
   if (state == 0)
   {
      if (btnp(B_START) == 1 || btnp(B_A) == 1)
         newGame();
      return;
   }
   if (state == 1)
   {
      playSteps++;
      moveHero();
      if (state == 1)
         moveFoes();
      return;
   }
   if (state == 2)
   {
      stateTime++;
      if (stateTime >= SLIDE)
         state = 1;
      return;
   }
   if (state == 3)
   {
      stateTime++;
      if (stateTime > 60 && (btnp(B_START) == 1 || btnp(B_A) == 1))
         state = 0;
   }
}

// --- drawing ---

// a screen of the world, its top-left at (ox, oy) of the screen's world part
void drawRoom(int r, int ox, int oy)
{
   for (int ty = 0; ty < 8; ty++)
      for (int tx = 0; tx < 10; tx++)
      {
         int t = tileAt(r, tx, ty);
         int n = A_GRASS;
         if (t == T_FLOWERS)
            n = A_FLOWERS;
         if (t == T_PATH)
            n = A_PATH;
         if (t == T_TREE)
            n = A_TREE;
         if (t == T_ROCK)
            n = A_ROCK;
         if (t == T_WATER)
         {
            n = A_WATER0;
            if ((frame / 16 + tx + ty) % 2 == 1)
               n = A_WATER1;
         }
         if (t == T_WALL)
            n = A_WALL;
         if (t == T_LOCKED)
            n = A_DOOR;
         if (t == T_OPEN)
            n = A_DOOROPEN;
         if (t == T_SHRINE)
            n = A_SHRINE;
         int x = ox + tx * 16;
         int y = TOP + oy + ty * 16;
         if (x >= 0 && x <= LW - 16 && y >= TOP && y <= LH - 16)
            tile(n, x, y);
         else
         {
            lfill(x, y, 16, 16, 0);
            blit(n, x, y, 0);
         }
         // what lies on the grass
         if (t == T_KEY)
            blit(A_KEY, x, y + (frame / 8) % 2, 0);
         if (t == T_SHARD)
            blit(A_SHARD, x, y - (frame / 8) % 2, 0);
         if (t == T_HEART)
            blit(A_HEART, x, y, 0);
      }
   // the shards given to the shrine shine on it
   if (r == 4)
      for (int k = 0; k < placed; k++)
         blit(A_SHARD, ox + 56 + k * 16, TOP + oy + 40 + (frame / 10 + k) % 2, 0);
}

void drawHero(int x, int y)
{
   if (hurt > 0 && (frame / 2) % 2 == 1)
      return;
   int step = 0;
   if (walking == 1 && (frame / 4) % 2 == 1)
      step = 1;
   int n = A_HERO_D0 + step;
   int flip = 0;
   if (facing == 1)
      n = A_HERO_U0 + step;
   if (facing == 2)
   {
      n = A_HERO_S0 + step;
      flip = 1;
   }
   if (facing == 3)
      n = A_HERO_S0 + step;
   if (swordTime > 0)
   {
      swordBox();
      int sx = x;
      int sy = y + 12;
      int s = A_SWORD_D;
      int sf = 0;
      if (facing == 1)
      {
         sy = y - 12;
         s = A_SWORD_U;
      }
      if (facing == 2)
      {
         sx = x - 12;
         sy = y + 2;
         s = A_SWORD_S;
         sf = 1;
      }
      if (facing == 3)
      {
         sx = x + 12;
         sy = y + 2;
         s = A_SWORD_S;
      }
      if (facing == 1)
         blit(s, sx, TOP + sy, sf);
      blit(n, x, TOP + y, flip);
      if (facing != 1)
         blit(s, sx, TOP + sy, sf);
      return;
   }
   blit(n, x, TOP + y, flip);
}

void drawFoes()
{
   for (int k = 0; k < FOES; k++)
   {
      if (etype[k] == 0)
         continue;
      if (eflash[k] > 0 && (frame / 2) % 2 == 1)
         continue;
      int n = A_SLIME0 + (frame / 8 + k) % 2;
      if (etype[k] == 2)
         n = A_BAT0 + (frame / 4 + k) % 2;
      blit(n, ex[k] / FP, TOP + ey[k] / FP, 0);
   }
   for (int k = 0; k < POOFS; k++)
      if (ptime[k] > 0 && (ptime[k] / 2) % 2 == 0)
         blit(A_POOF, px[k], TOP + py[k], 0);
}

void drawHud()
{
   lfill(0, 0, LW, TOP, 0);
   lfill(0, TOP - 1, LW, 1, 3);
   for (int k = 0; k < MAXHP; k++)
   {
      if (k < hp)
         icon(I_HUD_HEART, 4 + k * 9, 4);
      else
         icon(I_HUD_EMPTY, 4 + k * 9, 4);
   }
   if (hasKey == 1)
      icon(I_HUD_KEY, 92, 4);
   icon(I_HUD_SHARD, 112, 4);
   int x = number(shards, 124, 4, 3);
   // a slash, then 3
   for (int k = 0; k < 6; k++)
      lfill(x + 4 - k / 2, 5 + k, 1, 1, 3);
   text("3", x + 6, 4, 1, 3);
}

// the box at the bottom of the screen, two lines
void drawMessage()
{
   lfill(4, 102, 152, 38, 3);
   lfill(6, 104, 148, 34, 0);
   if (message == 1)
   {
      text("YOU FOUND", 12, 109, 1, 3);
      text("THE KEY", 12, 122, 1, 3);
   }
   if (message == 2)
   {
      text("A SHARD", 12, 109, 1, 3);
      int x = number(shards, 12, 122, 3);
      text("OF 3", x + 9, 122, 1, 3);
   }
   if (message == 3)
   {
      text("THE DOOR IS", 12, 109, 1, 3);
      text("LOCKED", 12, 122, 1, 3);
   }
   if (message == 4)
   {
      text("THE KEY TURNS", 12, 109, 1, 3);
      text("THE DOOR OPENS", 12, 122, 1, 3);
   }
   if (message == 5)
   {
      text("THE SHRINE", 12, 109, 1, 3);
      int x = number(placed, 12, 122, 3);
      text("OF 3 GLOW", x + 9, 122, 1, 3);
   }
   if (message == 6)
   {
      text("YOU WAKE AT", 12, 109, 1, 3);
      text("THE SHRINE", 12, 122, 1, 3);
   }
}

// B held: the screens seen so far
void drawMap()
{
   lfill(32, 28, 96, 92, 3);
   lfill(34, 30, 92, 88, 0);
   text("MAP", 66, 34, 1, 3);
   for (int r = 0; r < 9; r++)
   {
      int x = 44 + (r % 3) * 24;
      int y = 50 + (r / 3) * 20;
      if (visited[r] == 1)
         lfill(x, y, 22, 18, 1);
      else
         lfill(x, y, 22, 18, 2);
      if (r == room && (frame / 8) % 2 == 0)
         lfill(x + 7, y + 5, 8, 8, 3);
   }
}

void drawTitle()
{
   lfill(0, 0, LW, LH, 0);
   lfill(0, 100, LW, 44, 1);
   for (int x = 0; x < LW; x = x + 16)
      blit(A_TREE, x, 92, 0);
   text("MOSS", 44, 14, 2, 3);
   text("HOLLOW", 26, 36, 2, 3);
   blit(A_SHARD, 72, 62 + (frame / 10) % 2, 0);
   blit(A_HERO_D0, 72, 110, 0);
   if ((frame / 15) % 2 == 0)
      text("PRESS START", 31, 130, 1, 3);
}

void drawEnd()
{
   lfill(0, 0, LW, LH, 0);
   blit(A_SHRINE, 72, 30, 0);
   for (int k = 0; k < 3; k++)
      blit(A_SHARD, 56 + k * 16, 12 + (frame / 10 + k) % 2, 0);
   text("THE HOLLOW", 35, 58, 1, 3);
   text("IS WHOLE AGAIN", 17, 70, 1, 3);
   int secs = playSteps / 30;
   int x = number(secs / 60, 52, 90, 2);
   text("MIN", x + 4, 90, 1, 2);
   x = number(secs % 60, 52, 102, 2);
   text("SEC", x + 4, 102, 1, 2);
   if (stateTime > 60 && (frame / 15) % 2 == 0)
      text("PRESS START", 31, 126, 1, 3);
}

void draw()
{
   drawCase();
   clipTop = 0;
   clipBottom = LH;
   if (state == 0)
   {
      drawTitle();
      return;
   }
   if (state == 3)
   {
      drawEnd();
      return;
   }
   clipTop = TOP;
   if (state == 2)
   {
      // the old screen goes out as the new one comes in
      int d = stateTime * LW / SLIDE;
      int e = stateTime * (LH - TOP) / SLIDE;
      int ox = 0;
      int oy = 0;
      int nx = 0;
      int ny = 0;
      if (slideDir == 3)
      {
         ox = 0 - d;
         nx = LW - d;
      }
      if (slideDir == 2)
      {
         ox = d;
         nx = d - LW;
      }
      if (slideDir == 0)
      {
         oy = 0 - e;
         ny = LH - TOP - e;
      }
      if (slideDir == 1)
      {
         oy = e;
         ny = e - (LH - TOP);
      }
      drawRoom(oldRoom, ox, oy);
      drawRoom(room, nx, ny);
      drawHero(hx / FP + nx, hy / FP + ny);
   }
   else
   {
      drawRoom(room, 0, 0);
      drawFoes();
      drawHero(hx / FP, hy / FP);
   }
   clipTop = 0;
   drawHud();
   if (messageTime > 0)
      drawMessage();
   if (btn(B_B) == 1 && state == 1)
      drawMap();
}

int main()
{
   setPixelsize(2);           // 240x240, each 2x2 pixels
   makeColours();
   state = 0;
   held = 0;
   before = 0;
   uint32_t last = millis();
   while (true)
   {
      // fixed steps, 30 a second
      while (millis() - last >= STEP_MS)
      {
         last = last + STEP_MS;
         before = held;
         held = touchHeld;
         update();
      }
      draw();
      show16();
   }
}
)EOF";

// lcd.init() on core 0 so Bus_RGB's line copy interrupts stay off core 1, where the script draws
static void lcdInitTask(void *done) {
  lcd.init();
  lcd.setBrightness(255);
  xTaskNotifyGive((TaskHandle_t)done);
  vTaskDelete(NULL);
}

void setup() {
  Serial.begin(115200);
  xTaskCreatePinnedToCore(lcdInitTask, "lcdInit", 4096, xTaskGetCurrentTaskHandle(), 5, NULL, 0);
  ulTaskNotifyTake(pdTRUE, portMAX_DELAY);
  frame_buffer = (uint16_t *)lcd._bus_instance._frame_buffer;

  bindVariable((char *)"uint32_t", (char *)"width", NULL, (void *)&_sizex);
  bindVariable((char *)"uint32_t", (char *)"height", NULL, (void *)&_sizey);
  // a pointer, not an array: show16() swaps the frame buffers
  bindVariable((char *)"uint16_t *", (char *)"led16", NULL, (void *)&frame_buffer);
  bindVariable((char *)"uint32_t", (char *)"touchHeld", NULL, (void *)&touchHeld);
  bindFunction((char *)"void", (char *)"show16", NULL, (void *)show16);
  bindFunction((char *)"void", (char *)"setPixelsize", (char *)"int", (void *)setPixelsize);
  bindFunction((char *)"uint32_t", (char *)"millis", NULL, (void *)scriptMillis);
  bindFunction((char *)"uint32_t", (char *)"rand", (char *)"uint32_t", (void *)scriptRand);
  bindFunction((char *)"void", (char *)"setBrightness", (char *)"int", (void *)scriptSetBrightness);

  uint32_t t0 = millis();
  static ScriptExecutable exec = parseScript(mossHollow);
  if (!exec.isExeExists()) {
    showCompileError();
    return;
  }
  printf("moss hollow: %u bytes of code, compiled in %u ms\n", (unsigned)exec.exe.binary_size, (unsigned)(millis() - t0));

  // the touch screen, read on core 0
  xTaskCreatePinnedToCore(touchTask, "touch", 4096, NULL, 3, NULL, 0);

  exec.execute("main");
}

void loop() {
  delay(1000);
}
